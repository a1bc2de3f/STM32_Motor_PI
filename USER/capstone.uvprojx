# Keil uVision project capstone.uvprojx, settings and files
target capstone (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: capstone +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HAREWER\MOTO;..\HAREWER\ENCODER;..\HAREWER\TIMER;..\HAREWER\LED;..\HAREWER\KEY;..\BALANCE\CONTROL;..\HAREWER\DataScope_DP;..\HAREWER\EXTI;..\HAREWER\OLED;..\HAREWER\SHOW
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HAREWER
    ../HAREWER/MOTO/: moto.c
    ../HAREWER/ENCODER/: encoder.c
    ../HAREWER/TIMER/: timer.c
    ../HAREWER/LED/: led.c
    ../HAREWER/KEY/: key.c
    ../HAREWER/DataScope_DP/: DataScope_DP.C
    ../HAREWER/EXTI/: exti.c
    ../HAREWER/OLED/: oled.c
    ../HAREWER/SHOW/: show.c
  group BALANCE
    ../BALANCE/CONTROL/: control.c
